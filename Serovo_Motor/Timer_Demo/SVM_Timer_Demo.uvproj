# Keil uVision project SVM_Timer_Demo.uvproj, settings and files
target Target 1 (MCS-51)
  device: P89C51RD2Hxx NXP (founded by Philips)
  cpu: IRAM(0-0xFF) IROM(0-0xFFFF) XRAM(0-0x2FF) CLOCK(33000000) MODP2
  output: SVM_Timer_Demo +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 SVM_Timer_Demo.c
